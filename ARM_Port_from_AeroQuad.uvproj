# Keil uVision project ARM_Port_from_AeroQuad.uvproj, settings and files
target CortexM3_LPC1768 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: ARM_Port_from_AeroQuad
  c flags: Optim=1
  c include: .\libraries\EEPROM;.\libraries\Ethernet;.\libraries\Firmata;.\libraries\LiquidCrystal;.\libraries\Matrix;.\libraries\SD;.\libraries\SoftwareSerial;.\libraries\SPI;.\libraries\Sprite;.\libraries\Stepper;.\libraries\Wire
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source
    ./: startup_LPC17xx.s Accel.h AeroQuad.h Altitude.h AQMath.h BatteryMonitor.h Camera.h CHR6DM.h Compass.h DataAcquisition.h DataStorage.h FlightAngle.h GPS.h Gyro.h I2C.h Motors.h OSD.h PID.h Receiver.h Template.h AeroQuad.cpp FlightCommand.cpp FlightControl.cpp SerialCom.cpp
